// 自动生成，共 773 字
#include <cstring>
String charToPath(const char* ch) {
  if (strcmp(ch, "请") == 0) return "/words/0000.wav";
  if (strcmp(ch, "按") == 0) return "/words/0001.wav";
  if (strcmp(ch, "时") == 0) return "/words/0002.wav";
  if (strcmp(ch, "服") == 0) return "/words/0003.wav";
  if (strcmp(ch, "药") == 0) return "/words/0004.wav";
  if (strcmp(ch, "用") == 0) return "/words/0005.wav";
  if (strcmp(ch, "药") == 0) return "/words/0006.wav";
  if (strcmp(ch, "注") == 0) return "/words/0007.wav";
  if (strcmp(ch, "意") == 0) return "/words/0008.wav";
  if (strcmp(ch, "饮") == 0) return "/words/0009.wav";
  if (strcmp(ch, "食") == 0) return "/words/0010.wav";
  if (strcmp(ch, "禁") == 0) return "/words/0011.wav";
  if (strcmp(ch, "忌") == 0) return "/words/0012.wav";
  if (strcmp(ch, "观") == 0) return "/words/0013.wav";
  if (strcmp(ch, "察") == 0) return "/words/0014.wav";
  if (strcmp(ch, "反") == 0) return "/words/0015.wav";
  if (strcmp(ch, "应") == 0) return "/words/0016.wav";
  if (strcmp(ch, "多") == 0) return "/words/0017.wav";
  if (strcmp(ch, "喝") == 0) return "/words/0018.wav";
  if (strcmp(ch, "水") == 0) return "/words/0019.wav";
  if (strcmp(ch, "休") == 0) return "/words/0020.wav";
  if (strcmp(ch, "息") == 0) return "/words/0021.wav";
  if (strcmp(ch, "保") == 0) return "/words/0022.wav";
  if (strcmp(ch, "持") == 0) return "/words/0023.wav";
  if (strcmp(ch, "良") == 0) return "/words/0024.wav";
  if (strcmp(ch, "心") == 0) return "/words/0025.wav";
  if (strcmp(ch, "态") == 0) return "/words/0026.wav";
  if (strcmp(ch, "定") == 0) return "/words/0027.wav";
  if (strcmp(ch, "期") == 0) return "/words/0028.wav";
  if (strcmp(ch, "检") == 0) return "/words/0029.wav";
  if (strcmp(ch, "查") == 0) return "/words/0030.wav";
  if (strcmp(ch, "身") == 0) return "/words/0031.wav";
  if (strcmp(ch, "体") == 0) return "/words/0032.wav";
  if (strcmp(ch, "血") == 0) return "/words/0033.wav";
  if (strcmp(ch, "压") == 0) return "/words/0034.wav";
  if (strcmp(ch, "血") == 0) return "/words/0035.wav";
  if (strcmp(ch, "糖") == 0) return "/words/0036.wav";
  if (strcmp(ch, "控") == 0) return "/words/0037.wav";
  if (strcmp(ch, "制") == 0) return "/words/0038.wav";
  if (strcmp(ch, "记") == 0) return "/words/0039.wav";
  if (strcmp(ch, "监") == 0) return "/words/0040.wav";
  if (strcmp(ch, "测") == 0) return "/words/0041.wav";
  if (strcmp(ch, "变") == 0) return "/words/0042.wav";
  if (strcmp(ch, "化") == 0) return "/words/0043.wav";
  if (strcmp(ch, "如") == 0) return "/words/0044.wav";
  if (strcmp(ch, "果") == 0) return "/words/0045.wav";
  if (strcmp(ch, "出") == 0) return "/words/0046.wav";
  if (strcmp(ch, "现") == 0) return "/words/0047.wav";
  if (strcmp(ch, "不") == 0) return "/words/0048.wav";
  if (strcmp(ch, "适") == 0) return "/words/0049.wav";
  if (strcmp(ch, "立") == 0) return "/words/0050.wav";
  if (strcmp(ch, "即") == 0) return "/words/0051.wav";
  if (strcmp(ch, "停") == 0) return "/words/0052.wav";
  if (strcmp(ch, "药") == 0) return "/words/0053.wav";
  if (strcmp(ch, "就") == 0) return "/words/0054.wav";
  if (strcmp(ch, "医") == 0) return "/words/0055.wav";
  if (strcmp(ch, "咨") == 0) return "/words/0056.wav";
  if (strcmp(ch, "询") == 0) return "/words/0057.wav";
  if (strcmp(ch, "医") == 0) return "/words/0058.wav";
  if (strcmp(ch, "生") == 0) return "/words/0059.wav";
  if (strcmp(ch, "师") == 0) return "/words/0060.wav";
  if (strcmp(ch, "克") == 0) return "/words/0061.wav";
  if (strcmp(ch, "增") == 0) return "/words/0062.wav";
  if (strcmp(ch, "减") == 0) return "/words/0063.wav";
  if (strcmp(ch, "调") == 0) return "/words/0064.wav";
  if (strcmp(ch, "整") == 0) return "/words/0065.wav";
  if (strcmp(ch, "量") == 0) return "/words/0066.wav";
  if (strcmp(ch, "早") == 0) return "/words/0067.wav";
  if (strcmp(ch, "晚") == 0) return "/words/0068.wav";
  if (strcmp(ch, "空") == 0) return "/words/0069.wav";
  if (strcmp(ch, "腹") == 0) return "/words/0070.wav";
  if (strcmp(ch, "饱") == 0) return "/words/0071.wav";
  if (strcmp(ch, "后") == 0) return "/words/0072.wav";
  if (strcmp(ch, "服") == 0) return "/words/0073.wav";
  if (strcmp(ch, "前") == 0) return "/words/0074.wav";
  if (strcmp(ch, "小") == 0) return "/words/0075.wav";
  if (strcmp(ch, "时") == 0) return "/words/0076.wav";
  if (strcmp(ch, "分") == 0) return "/words/0077.wav";
  if (strcmp(ch, "钟") == 0) return "/words/0078.wav";
  if (strcmp(ch, "次") == 0) return "/words/0079.wav";
  if (strcmp(ch, "粒") == 0) return "/words/0080.wav";
  if (strcmp(ch, "片") == 0) return "/words/0081.wav";
  if (strcmp(ch, "毫") == 0) return "/words/0082.wav";
  if (strcmp(ch, "升") == 0) return "/words/0083.wav";
  if (strcmp(ch, "包") == 0) return "/words/0084.wav";
  if (strcmp(ch, "瓶") == 0) return "/words/0085.wav";
  if (strcmp(ch, "支") == 0) return "/words/0086.wav";
  if (strcmp(ch, "温") == 0) return "/words/0087.wav";
  if (strcmp(ch, "度") == 0) return "/words/0088.wav";
  if (strcmp(ch, "计") == 0) return "/words/0089.wav";
  if (strcmp(ch, "测") == 0) return "/words/0090.wav";
  if (strcmp(ch, "量") == 0) return "/words/0091.wav";
  if (strcmp(ch, "超") == 0) return "/words/0092.wav";
  if (strcmp(ch, "过") == 0) return "/words/0093.wav";
  if (strcmp(ch, "期") == 0) return "/words/0094.wav";
  if (strcmp(ch, "品") == 0) return "/words/0095.wav";
  if (strcmp(ch, "丢") == 0) return "/words/0096.wav";
  if (strcmp(ch, "弃") == 0) return "/words/0097.wav";
  if (strcmp(ch, "勿") == 0) return "/words/0098.wav";
  if (strcmp(ch, "继") == 0) return "/words/0099.wav";
  if (strcmp(ch, "续") == 0) return "/words/0100.wav";
  if (strcmp(ch, "吸") == 0) return "/words/0101.wav";
  if (strcmp(ch, "困") == 0) return "/words/0102.wav";
  if (strcmp(ch, "难") == 0) return "/words/0103.wav";
  if (strcmp(ch, "胸") == 0) return "/words/0104.wav";
  if (strcmp(ch, "闷") == 0) return "/words/0105.wav";
  if (strcmp(ch, "头") == 0) return "/words/0106.wav";
  if (strcmp(ch, "晕") == 0) return "/words/0107.wav";
  if (strcmp(ch, "恶") == 0) return "/words/0108.wav";
  if (strcmp(ch, "心") == 0) return "/words/0109.wav";
  if (strcmp(ch, "呕") == 0) return "/words/0110.wav";
  if (strcmp(ch, "吐") == 0) return "/words/0111.wav";
  if (strcmp(ch, "腹") == 0) return "/words/0112.wav";
  if (strcmp(ch, "泻") == 0) return "/words/0113.wav";
  if (strcmp(ch, "便") == 0) return "/words/0114.wav";
  if (strcmp(ch, "秘") == 0) return "/words/0115.wav";
  if (strcmp(ch, "皮") == 0) return "/words/0116.wav";
  if (strcmp(ch, "疹") == 0) return "/words/0117.wav";
  if (strcmp(ch, "红") == 0) return "/words/0118.wav";
  if (strcmp(ch, "肿") == 0) return "/words/0119.wav";
  if (strcmp(ch, "痒") == 0) return "/words/0120.wav";
  if (strcmp(ch, "痛") == 0) return "/words/0121.wav";
  if (strcmp(ch, "过") == 0) return "/words/0122.wav";
  if (strcmp(ch, "敏") == 0) return "/words/0123.wav";
  if (strcmp(ch, "史") == 0) return "/words/0124.wav";
  if (strcmp(ch, "肝") == 0) return "/words/0125.wav";
  if (strcmp(ch, "肾") == 0) return "/words/0126.wav";
  if (strcmp(ch, "功") == 0) return "/words/0127.wav";
  if (strcmp(ch, "能") == 0) return "/words/0128.wav";
  if (strcmp(ch, "异") == 0) return "/words/0129.wav";
  if (strcmp(ch, "常") == 0) return "/words/0130.wav";
  if (strcmp(ch, "妊") == 0) return "/words/0131.wav";
  if (strcmp(ch, "娠") == 0) return "/words/0132.wav";
  if (strcmp(ch, "哺") == 0) return "/words/0133.wav";
  if (strcmp(ch, "乳") == 0) return "/words/0134.wav";
  if (strcmp(ch, "期") == 0) return "/words/0135.wav";
  if (strcmp(ch, "妇") == 0) return "/words/0136.wav";
  if (strcmp(ch, "女") == 0) return "/words/0137.wav";
  if (strcmp(ch, "童") == 0) return "/words/0138.wav";
  if (strcmp(ch, "老") == 0) return "/words/0139.wav";
  if (strcmp(ch, "年") == 0) return "/words/0140.wav";
  if (strcmp(ch, "人") == 0) return "/words/0141.wav";
  if (strcmp(ch, "慎") == 0) return "/words/0142.wav";
  if (strcmp(ch, "用") == 0) return "/words/0143.wav";
  if (strcmp(ch, "禁") == 0) return "/words/0144.wav";
  if (strcmp(ch, "酒") == 0) return "/words/0145.wav";
  if (strcmp(ch, "驾") == 0) return "/words/0146.wav";
  if (strcmp(ch, "机") == 0) return "/words/0147.wav";
  if (strcmp(ch, "械") == 0) return "/words/0148.wav";
  if (strcmp(ch, "操") == 0) return "/words/0149.wav";
  if (strcmp(ch, "作") == 0) return "/words/0150.wav";
  if (strcmp(ch, "贮") == 0) return "/words/0151.wav";
  if (strcmp(ch, "藏") == 0) return "/words/0152.wav";
  if (strcmp(ch, "阴") == 0) return "/words/0153.wav";
  if (strcmp(ch, "凉") == 0) return "/words/0154.wav";
  if (strcmp(ch, "干") == 0) return "/words/0155.wav";
  if (strcmp(ch, "燥") == 0) return "/words/0156.wav";
  if (strcmp(ch, "处") == 0) return "/words/0157.wav";
  if (strcmp(ch, "避") == 0) return "/words/0158.wav";
  if (strcmp(ch, "光") == 0) return "/words/0159.wav";
  if (strcmp(ch, "密") == 0) return "/words/0160.wav";
  if (strcmp(ch, "封") == 0) return "/words/0161.wav";
  if (strcmp(ch, "保") == 0) return "/words/0162.wav";
  if (strcmp(ch, "存") == 0) return "/words/0163.wav";
  if (strcmp(ch, "效") == 0) return "/words/0164.wav";
  if (strcmp(ch, "说") == 0) return "/words/0165.wav";
  if (strcmp(ch, "明") == 0) return "/words/0166.wav";
  if (strcmp(ch, "书") == 0) return "/words/0167.wav";
  if (strcmp(ch, "成") == 0) return "/words/0168.wav";
  if (strcmp(ch, "分") == 0) return "/words/0169.wav";
  if (strcmp(ch, "作") == 0) return "/words/0170.wav";
  if (strcmp(ch, "用") == 0) return "/words/0171.wav";
  if (strcmp(ch, "类") == 0) return "/words/0172.wav";
  if (strcmp(ch, "别") == 0) return "/words/0173.wav";
  if (strcmp(ch, "甲") == 0) return "/words/0174.wav";
  if (strcmp(ch, "硝") == 0) return "/words/0175.wav";
  if (strcmp(ch, "阿") == 0) return "/words/0176.wav";
  if (strcmp(ch, "莫") == 0) return "/words/0177.wav";
  if (strcmp(ch, "西") == 0) return "/words/0178.wav";
  if (strcmp(ch, "林") == 0) return "/words/0179.wav";
  if (strcmp(ch, "头") == 0) return "/words/0180.wav";
  if (strcmp(ch, "孢") == 0) return "/words/0181.wav";
  if (strcmp(ch, "克") == 0) return "/words/0182.wav";
  if (strcmp(ch, "洛") == 0) return "/words/0183.wav";
  if (strcmp(ch, "红") == 0) return "/words/0184.wav";
  if (strcmp(ch, "霉") == 0) return "/words/0185.wav";
  if (strcmp(ch, "布") == 0) return "/words/0186.wav";
  if (strcmp(ch, "洛") == 0) return "/words/0187.wav";
  if (strcmp(ch, "芬") == 0) return "/words/0188.wav";
  if (strcmp(ch, "对") == 0) return "/words/0189.wav";
  if (strcmp(ch, "乙") == 0) return "/words/0190.wav";
  if (strcmp(ch, "酰") == 0) return "/words/0191.wav";
  if (strcmp(ch, "氨") == 0) return "/words/0192.wav";
  if (strcmp(ch, "基") == 0) return "/words/0193.wav";
  if (strcmp(ch, "酚") == 0) return "/words/0194.wav";
  if (strcmp(ch, "阿") == 0) return "/words/0195.wav";
  if (strcmp(ch, "司") == 0) return "/words/0196.wav";
  if (strcmp(ch, "匹") == 0) return "/words/0197.wav";
  if (strcmp(ch, "林") == 0) return "/words/0198.wav";
  if (strcmp(ch, "奥") == 0) return "/words/0199.wav";
  if (strcmp(ch, "美") == 0) return "/words/0200.wav";
  if (strcmp(ch, "拉") == 0) return "/words/0201.wav";
  if (strcmp(ch, "唑") == 0) return "/words/0202.wav";
  if (strcmp(ch, "蒙") == 0) return "/words/0203.wav";
  if (strcmp(ch, "脱") == 0) return "/words/0204.wav";
  if (strcmp(ch, "石") == 0) return "/words/0205.wav";
  if (strcmp(ch, "散") == 0) return "/words/0206.wav";
  if (strcmp(ch, "硝") == 0) return "/words/0207.wav";
  if (strcmp(ch, "酸") == 0) return "/words/0208.wav";
  if (strcmp(ch, "甘") == 0) return "/words/0209.wav";
  if (strcmp(ch, "油") == 0) return "/words/0210.wav";
  if (strcmp(ch, "他") == 0) return "/words/0211.wav";
  if (strcmp(ch, "汀") == 0) return "/words/0212.wav";
  if (strcmp(ch, "类") == 0) return "/words/0213.wav";
  if (strcmp(ch, "降") == 0) return "/words/0214.wav";
  if (strcmp(ch, "压") == 0) return "/words/0215.wav";
  if (strcmp(ch, "降") == 0) return "/words/0216.wav";
  if (strcmp(ch, "糖") == 0) return "/words/0217.wav";
  if (strcmp(ch, "药") == 0) return "/words/0218.wav";
  if (strcmp(ch, "钙") == 0) return "/words/0219.wav";
  if (strcmp(ch, "通") == 0) return "/words/0220.wav";
  if (strcmp(ch, "便") == 0) return "/words/0221.wav";
  if (strcmp(ch, "止") == 0) return "/words/0222.wav";
  if (strcmp(ch, "咳") == 0) return "/words/0223.wav";
  if (strcmp(ch, "化") == 0) return "/words/0224.wav";
  if (strcmp(ch, "痰") == 0) return "/words/0225.wav";
  if (strcmp(ch, "平") == 0) return "/words/0226.wav";
  if (strcmp(ch, "喘") == 0) return "/words/0227.wav";
  if (strcmp(ch, "消") == 0) return "/words/0228.wav";
  if (strcmp(ch, "心") == 0) return "/words/0229.wav";
  if (strcmp(ch, "痛") == 0) return "/words/0230.wav";
  if (strcmp(ch, "胃") == 0) return "/words/0231.wav";
  if (strcmp(ch, "药") == 0) return "/words/0232.wav";
  if (strcmp(ch, "外") == 0) return "/words/0233.wav";
  if (strcmp(ch, "贴") == 0) return "/words/0234.wav";
  if (strcmp(ch, "膏") == 0) return "/words/0235.wav";
  if (strcmp(ch, "药") == 0) return "/words/0236.wav";
  if (strcmp(ch, "丸") == 0) return "/words/0237.wav";
  if (strcmp(ch, "剂") == 0) return "/words/0238.wav";
  if (strcmp(ch, "胶") == 0) return "/words/0239.wav";
  if (strcmp(ch, "囊") == 0) return "/words/0240.wav";
  if (strcmp(ch, "冲") == 0) return "/words/0241.wav";
  if (strcmp(ch, "颗") == 0) return "/words/0242.wav";
  if (strcmp(ch, "粒") == 0) return "/words/0243.wav";
  if (strcmp(ch, "口") == 0) return "/words/0244.wav";
  if (strcmp(ch, "服") == 0) return "/words/0245.wav";
  if (strcmp(ch, "液") == 0) return "/words/0246.wav";
  if (strcmp(ch, "注") == 0) return "/words/0247.wav";
  if (strcmp(ch, "射") == 0) return "/words/0248.wav";
  if (strcmp(ch, "慢") == 0) return "/words/0249.wav";
  if (strcmp(ch, "性") == 0) return "/words/0250.wav";
  if (strcmp(ch, "病") == 0) return "/words/0251.wav";
  if (strcmp(ch, "冠") == 0) return "/words/0252.wav";
  if (strcmp(ch, "心") == 0) return "/words/0253.wav";
  if (strcmp(ch, "病") == 0) return "/words/0254.wav";
  if (strcmp(ch, "塞") == 0) return "/words/0255.wav";
  if (strcmp(ch, "脑") == 0) return "/words/0256.wav";
  if (strcmp(ch, "卒") == 0) return "/words/0257.wav";
  if (strcmp(ch, "中") == 0) return "/words/0258.wav";
  if (strcmp(ch, "梗") == 0) return "/words/0259.wav";
  if (strcmp(ch, "死") == 0) return "/words/0260.wav";
  if (strcmp(ch, "凝") == 0) return "/words/0261.wav";
  if (strcmp(ch, "活") == 0) return "/words/0262.wav";
  if (strcmp(ch, "血") == 0) return "/words/0263.wav";
  if (strcmp(ch, "祛") == 0) return "/words/0264.wav";
  if (strcmp(ch, "瓣") == 0) return "/words/0265.wav";
  if (strcmp(ch, "膜") == 0) return "/words/0266.wav";
  if (strcmp(ch, "房") == 0) return "/words/0267.wav";
  if (strcmp(ch, "颤") == 0) return "/words/0268.wav";
  if (strcmp(ch, "扑") == 0) return "/words/0269.wav";
  if (strcmp(ch, "动") == 0) return "/words/0270.wav";
  if (strcmp(ch, "素") == 0) return "/words/0271.wav";
  if (strcmp(ch, "拉") == 0) return "/words/0272.wav";
  if (strcmp(ch, "唑") == 0) return "/words/0273.wav";
  if (strcmp(ch, "奈") == 0) return "/words/0274.wav";
  if (strcmp(ch, "普") == 0) return "/words/0275.wav";
  if (strcmp(ch, "生") == 0) return "/words/0276.wav";
  if (strcmp(ch, "美") == 0) return "/words/0277.wav";
  if (strcmp(ch, "敏") == 0) return "/words/0278.wav";
  if (strcmp(ch, "麻") == 0) return "/words/0279.wav";
  if (strcmp(ch, "伪") == 0) return "/words/0280.wav";
  if (strcmp(ch, "麻") == 0) return "/words/0281.wav";
  if (strcmp(ch, "黄") == 0) return "/words/0282.wav";
  if (strcmp(ch, "碱") == 0) return "/words/0283.wav";
  if (strcmp(ch, "福") == 0) return "/words/0284.wav";
  if (strcmp(ch, "平") == 0) return "/words/0285.wav";
  if (strcmp(ch, "异") == 0) return "/words/0286.wav";
  if (strcmp(ch, "烟") == 0) return "/words/0287.wav";
  if (strcmp(ch, "肼") == 0) return "/words/0288.wav";
  if (strcmp(ch, "吡") == 0) return "/words/0289.wav";
  if (strcmp(ch, "啶") == 0) return "/words/0290.wav";
  if (strcmp(ch, "酰") == 0) return "/words/0291.wav";
  if (strcmp(ch, "胺") == 0) return "/words/0292.wav";
  if (strcmp(ch, "奎") == 0) return "/words/0293.wav";
  if (strcmp(ch, "宁") == 0) return "/words/0294.wav";
  if (strcmp(ch, "可") == 0) return "/words/0295.wav";
  if (strcmp(ch, "待") == 0) return "/words/0296.wav";
  if (strcmp(ch, "因") == 0) return "/words/0297.wav";
  if (strcmp(ch, "曲") == 0) return "/words/0298.wav";
  if (strcmp(ch, "马") == 0) return "/words/0299.wav";
  if (strcmp(ch, "多") == 0) return "/words/0300.wav";
  if (strcmp(ch, "酮") == 0) return "/words/0301.wav";
  if (strcmp(ch, "替") == 0) return "/words/0302.wav";
  if (strcmp(ch, "芬") == 0) return "/words/0303.wav";
  if (strcmp(ch, "氯") == 0) return "/words/0304.wav";
  if (strcmp(ch, "雷") == 0) return "/words/0305.wav";
  if (strcmp(ch, "他") == 0) return "/words/0306.wav";
  if (strcmp(ch, "定") == 0) return "/words/0307.wav";
  if (strcmp(ch, "西") == 0) return "/words/0308.wav";
  if (strcmp(ch, "替") == 0) return "/words/0309.wav";
  if (strcmp(ch, "利") == 0) return "/words/0310.wav";
  if (strcmp(ch, "嗪") == 0) return "/words/0311.wav";
  if (strcmp(ch, "泼") == 0) return "/words/0312.wav";
  if (strcmp(ch, "尼") == 0) return "/words/0313.wav";
  if (strcmp(ch, "松") == 0) return "/words/0314.wav";
  if (strcmp(ch, "龙") == 0) return "/words/0315.wav";
  if (strcmp(ch, "地") == 0) return "/words/0316.wav";
  if (strcmp(ch, "塞") == 0) return "/words/0317.wav";
  if (strcmp(ch, "米") == 0) return "/words/0318.wav";
  if (strcmp(ch, "松") == 0) return "/words/0319.wav";
  if (strcmp(ch, "胰") == 0) return "/words/0320.wav";
  if (strcmp(ch, "岛") == 0) return "/words/0321.wav";
  if (strcmp(ch, "格") == 0) return "/words/0322.wav";
  if (strcmp(ch, "列") == 0) return "/words/0323.wav";
  if (strcmp(ch, "齐") == 0) return "/words/0324.wav";
  if (strcmp(ch, "特") == 0) return "/words/0325.wav";
  if (strcmp(ch, "胍") == 0) return "/words/0326.wav";
  if (strcmp(ch, "阿") == 0) return "/words/0327.wav";
  if (strcmp(ch, "卡") == 0) return "/words/0328.wav";
  if (strcmp(ch, "波") == 0) return "/words/0329.wav";
  if (strcmp(ch, "糖") == 0) return "/words/0330.wav";
  if (strcmp(ch, "罗") == 0) return "/words/0331.wav";
  if (strcmp(ch, "格") == 0) return "/words/0332.wav";
  if (strcmp(ch, "列") == 0) return "/words/0333.wav";
  if (strcmp(ch, "酮") == 0) return "/words/0334.wav";
  if (strcmp(ch, "肽") == 0) return "/words/0335.wav";
  if (strcmp(ch, "氨") == 0) return "/words/0336.wav";
  if (strcmp(ch, "氯") == 0) return "/words/0337.wav";
  if (strcmp(ch, "地") == 0) return "/words/0338.wav";
  if (strcmp(ch, "平") == 0) return "/words/0339.wav";
  if (strcmp(ch, "氟") == 0) return "/words/0340.wav";
  if (strcmp(ch, "沙") == 0) return "/words/0341.wav";
  if (strcmp(ch, "坦") == 0) return "/words/0342.wav";
  if (strcmp(ch, "卡") == 0) return "/words/0343.wav";
  if (strcmp(ch, "托") == 0) return "/words/0344.wav";
  if (strcmp(ch, "普") == 0) return "/words/0345.wav";
  if (strcmp(ch, "利") == 0) return "/words/0346.wav";
  if (strcmp(ch, "伐") == 0) return "/words/0347.wav";
  if (strcmp(ch, "他") == 0) return "/words/0348.wav";
  if (strcmp(ch, "汀") == 0) return "/words/0349.wav";
  if (strcmp(ch, "诺") == 0) return "/words/0350.wav";
  if (strcmp(ch, "贝") == 0) return "/words/0351.wav";
  if (strcmp(ch, "特") == 0) return "/words/0352.wav";
  if (strcmp(ch, "尔") == 0) return "/words/0353.wav";
  if (strcmp(ch, "考") == 0) return "/words/0354.wav";
  if (strcmp(ch, "昔") == 0) return "/words/0355.wav";
  if (strcmp(ch, "康") == 0) return "/words/0356.wav";
  if (strcmp(ch, "苯") == 0) return "/words/0357.wav";
  if (strcmp(ch, "溴") == 0) return "/words/0358.wav";
  if (strcmp(ch, "马") == 0) return "/words/0359.wav";
  if (strcmp(ch, "隆") == 0) return "/words/0360.wav";
  if (strcmp(ch, "别") == 0) return "/words/0361.wav";
  if (strcmp(ch, "嘌") == 0) return "/words/0362.wav";
  if (strcmp(ch, "醇") == 0) return "/words/0363.wav";
  if (strcmp(ch, "胞") == 0) return "/words/0364.wav";
  if (strcmp(ch, "磷") == 0) return "/words/0365.wav";
  if (strcmp(ch, "胆") == 0) return "/words/0366.wav";
  if (strcmp(ch, "碱") == 0) return "/words/0367.wav";
  if (strcmp(ch, "尼") == 0) return "/words/0368.wav";
  if (strcmp(ch, "莫") == 0) return "/words/0369.wav";
  if (strcmp(ch, "地") == 0) return "/words/0370.wav";
  if (strcmp(ch, "长") == 0) return "/words/0371.wav";
  if (strcmp(ch, "春") == 0) return "/words/0372.wav";
  if (strcmp(ch, "西") == 0) return "/words/0373.wav";
  if (strcmp(ch, "汀") == 0) return "/words/0374.wav";
  if (strcmp(ch, "胞") == 0) return "/words/0375.wav";
  if (strcmp(ch, "苷") == 0) return "/words/0376.wav";
  if (strcmp(ch, "二") == 0) return "/words/0377.wav";
  if (strcmp(ch, "磷") == 0) return "/words/0378.wav";
  if (strcmp(ch, "加") == 0) return "/words/0379.wav";
  if (strcmp(ch, "兰") == 0) return "/words/0380.wav";
  if (strcmp(ch, "他") == 0) return "/words/0381.wav";
  if (strcmp(ch, "敏") == 0) return "/words/0382.wav";
  if (strcmp(ch, "培") == 0) return "/words/0383.wav";
  if (strcmp(ch, "南") == 0) return "/words/0384.wav";
  if (strcmp(ch, "左") == 0) return "/words/0385.wav";
  if (strcmp(ch, "氧") == 0) return "/words/0386.wav";
  if (strcmp(ch, "氟") == 0) return "/words/0387.wav";
  if (strcmp(ch, "沙") == 0) return "/words/0388.wav";
  if (strcmp(ch, "星") == 0) return "/words/0389.wav";
  if (strcmp(ch, "庆") == 0) return "/words/0390.wav";
  if (strcmp(ch, "大") == 0) return "/words/0391.wav";
  if (strcmp(ch, "霄") == 0) return "/words/0392.wav";
  if (strcmp(ch, "素") == 0) return "/words/0393.wav";
  if (strcmp(ch, "呋") == 0) return "/words/0394.wav";
  if (strcmp(ch, "辛") == 0) return "/words/0395.wav";
  if (strcmp(ch, "磺") == 0) return "/words/0396.wav";
  if (strcmp(ch, "胺") == 0) return "/words/0397.wav";
  if (strcmp(ch, "嘧") == 0) return "/words/0398.wav";
  if (strcmp(ch, "啶") == 0) return "/words/0399.wav";
  if (strcmp(ch, "参") == 0) return "/words/0400.wav";
  if (strcmp(ch, "麦") == 0) return "/words/0401.wav";
  if (strcmp(ch, "冬") == 0) return "/words/0402.wav";
  if (strcmp(ch, "五") == 0) return "/words/0403.wav";
  if (strcmp(ch, "味") == 0) return "/words/0404.wav";
  if (strcmp(ch, "子") == 0) return "/words/0405.wav";
  if (strcmp(ch, "枸") == 0) return "/words/0406.wav";
  if (strcmp(ch, "杞") == 0) return "/words/0407.wav";
  if (strcmp(ch, "菊") == 0) return "/words/0408.wav";
  if (strcmp(ch, "花") == 0) return "/words/0409.wav";
  if (strcmp(ch, "生") == 0) return "/words/0410.wav";
  if (strcmp(ch, "脉") == 0) return "/words/0411.wav";
  if (strcmp(ch, "饮") == 0) return "/words/0412.wav";
  if (strcmp(ch, "肾") == 0) return "/words/0413.wav";
  if (strcmp(ch, "气") == 0) return "/words/0414.wav";
  if (strcmp(ch, "丸") == 0) return "/words/0415.wav";
  if (strcmp(ch, "六") == 0) return "/words/0416.wav";
  if (strcmp(ch, "味") == 0) return "/words/0417.wav";
  if (strcmp(ch, "地") == 0) return "/words/0418.wav";
  if (strcmp(ch, "黄") == 0) return "/words/0419.wav";
  if (strcmp(ch, "知") == 0) return "/words/0420.wav";
  if (strcmp(ch, "柏") == 0) return "/words/0421.wav";
  if (strcmp(ch, "附") == 0) return "/words/0422.wav";
  if (strcmp(ch, "子") == 0) return "/words/0423.wav";
  if (strcmp(ch, "理") == 0) return "/words/0424.wav";
  if (strcmp(ch, "中") == 0) return "/words/0425.wav";
  if (strcmp(ch, "十") == 0) return "/words/0426.wav";
  if (strcmp(ch, "全") == 0) return "/words/0427.wav";
  if (strcmp(ch, "大") == 0) return "/words/0428.wav";
  if (strcmp(ch, "补") == 0) return "/words/0429.wav";
  if (strcmp(ch, "汤") == 0) return "/words/0430.wav";
  if (strcmp(ch, "归") == 0) return "/words/0431.wav";
  if (strcmp(ch, "脾") == 0) return "/words/0432.wav";
  if (strcmp(ch, "逍") == 0) return "/words/0433.wav";
  if (strcmp(ch, "遥") == 0) return "/words/0434.wav";
  if (strcmp(ch, "散") == 0) return "/words/0435.wav";
  if (strcmp(ch, "龙") == 0) return "/words/0436.wav";
  if (strcmp(ch, "胆") == 0) return "/words/0437.wav";
  if (strcmp(ch, "泻") == 0) return "/words/0438.wav";
  if (strcmp(ch, "肝") == 0) return "/words/0439.wav";
  if (strcmp(ch, "温") == 0) return "/words/0440.wav";
  if (strcmp(ch, "胆") == 0) return "/words/0441.wav";
  if (strcmp(ch, "汤") == 0) return "/words/0442.wav";
  if (strcmp(ch, "安") == 0) return "/words/0443.wav";
  if (strcmp(ch, "宫") == 0) return "/words/0444.wav";
  if (strcmp(ch, "牛") == 0) return "/words/0445.wav";
  if (strcmp(ch, "黄") == 0) return "/words/0446.wav";
  if (strcmp(ch, "清") == 0) return "/words/0447.wav";
  if (strcmp(ch, "热") == 0) return "/words/0448.wav";
  if (strcmp(ch, "解") == 0) return "/words/0449.wav";
  if (strcmp(ch, "毒") == 0) return "/words/0450.wav";
  if (strcmp(ch, "凉") == 0) return "/words/0451.wav";
  if (strcmp(ch, "血") == 0) return "/words/0452.wav";
  if (strcmp(ch, "止") == 0) return "/words/0453.wav";
  if (strcmp(ch, "血") == 0) return "/words/0454.wav";
  if (strcmp(ch, "生") == 0) return "/words/0455.wav";
  if (strcmp(ch, "津") == 0) return "/words/0456.wav";
  if (strcmp(ch, "润") == 0) return "/words/0457.wav";
  if (strcmp(ch, "燥") == 0) return "/words/0458.wav";
  if (strcmp(ch, "疏") == 0) return "/words/0459.wav";
  if (strcmp(ch, "肝") == 0) return "/words/0460.wav";
  if (strcmp(ch, "健") == 0) return "/words/0461.wav";
  if (strcmp(ch, "益") == 0) return "/words/0462.wav";
  if (strcmp(ch, "养") == 0) return "/words/0463.wav";
  if (strcmp(ch, "心") == 0) return "/words/0464.wav";
  if (strcmp(ch, "安") == 0) return "/words/0465.wav";
  if (strcmp(ch, "神") == 0) return "/words/0466.wav";
  if (strcmp(ch, "定") == 0) return "/words/0467.wav";
  if (strcmp(ch, "志") == 0) return "/words/0468.wav";
  if (strcmp(ch, "通") == 0) return "/words/0469.wav";
  if (strcmp(ch, "窍") == 0) return "/words/0470.wav";
  if (strcmp(ch, "聪") == 0) return "/words/0471.wav";
  if (strcmp(ch, "耳") == 0) return "/words/0472.wav";
  if (strcmp(ch, "目") == 0) return "/words/0473.wav";
  if (strcmp(ch, "明") == 0) return "/words/0474.wav";
  if (strcmp(ch, "咽") == 0) return "/words/0475.wav";
  if (strcmp(ch, "利") == 0) return "/words/0476.wav";
  if (strcmp(ch, "喉") == 0) return "/words/0477.wav";
  if (strcmp(ch, "消") == 0) return "/words/0478.wav";
  if (strcmp(ch, "食") == 0) return "/words/0479.wav";
  if (strcmp(ch, "导") == 0) return "/words/0480.wav";
  if (strcmp(ch, "滞") == 0) return "/words/0481.wav";
  if (strcmp(ch, "化") == 0) return "/words/0482.wav";
  if (strcmp(ch, "浊") == 0) return "/words/0483.wav";
  if (strcmp(ch, "降") == 0) return "/words/0484.wav";
  if (strcmp(ch, "脂") == 0) return "/words/0485.wav";
  if (strcmp(ch, "松") == 0) return "/words/0486.wav";
  if (strcmp(ch, "解") == 0) return "/words/0487.wav";
  if (strcmp(ch, "痉") == 0) return "/words/0488.wav";
  if (strcmp(ch, "平") == 0) return "/words/0489.wav";
  if (strcmp(ch, "与") == 0) return "/words/0490.wav";
  if (strcmp(ch, "用") == 0) return "/words/0491.wav";
  if (strcmp(ch, "法") == 0) return "/words/0492.wav";
  if (strcmp(ch, "治") == 0) return "/words/0493.wav";
  if (strcmp(ch, "原") == 0) return "/words/0494.wav";
  if (strcmp(ch, "材") == 0) return "/words/0495.wav";
  if (strcmp(ch, "制") == 0) return "/words/0496.wav";
  if (strcmp(ch, "煎") == 0) return "/words/0497.wav";
  if (strcmp(ch, "煮") == 0) return "/words/0498.wav";
  if (strcmp(ch, "熬") == 0) return "/words/0499.wav";
  if (strcmp(ch, "炖") == 0) return "/words/0500.wav";
  if (strcmp(ch, "泡") == 0) return "/words/0501.wav";
  if (strcmp(ch, "浸") == 0) return "/words/0502.wav";
  if (strcmp(ch, "榨") == 0) return "/words/0503.wav";
  if (strcmp(ch, "取") == 0) return "/words/0504.wav";
  if (strcmp(ch, "汁") == 0) return "/words/0505.wav";
  if (strcmp(ch, "去") == 0) return "/words/0506.wav";
  if (strcmp(ch, "渣") == 0) return "/words/0507.wav";
  if (strcmp(ch, "滤") == 0) return "/words/0508.wav";
  if (strcmp(ch, "净") == 0) return "/words/0509.wav";
  if (strcmp(ch, "均") == 0) return "/words/0510.wav";
  if (strcmp(ch, "搅") == 0) return "/words/0511.wav";
  if (strcmp(ch, "拌") == 0) return "/words/0512.wav";
  if (strcmp(ch, "敷") == 0) return "/words/0513.wav";
  if (strcmp(ch, "涂") == 0) return "/words/0514.wav";
  if (strcmp(ch, "擦") == 0) return "/words/0515.wav";
  if (strcmp(ch, "拭") == 0) return "/words/0516.wav";
  if (strcmp(ch, "清") == 0) return "/words/0517.wav";
  if (strcmp(ch, "创") == 0) return "/words/0518.wav";
  if (strcmp(ch, "包") == 0) return "/words/0519.wav";
  if (strcmp(ch, "扎") == 0) return "/words/0520.wav";
  if (strcmp(ch, "固") == 0) return "/words/0521.wav";
  if (strcmp(ch, "定") == 0) return "/words/0522.wav";
  if (strcmp(ch, "夹") == 0) return "/words/0523.wav";
  if (strcmp(ch, "板") == 0) return "/words/0524.wav";
  if (strcmp(ch, "牵") == 0) return "/words/0525.wav";
  if (strcmp(ch, "引") == 0) return "/words/0526.wav";
  if (strcmp(ch, "按") == 0) return "/words/0527.wav";
  if (strcmp(ch, "揉") == 0) return "/words/0528.wav";
  if (strcmp(ch, "推") == 0) return "/words/0529.wav";
  if (strcmp(ch, "拿") == 0) return "/words/0530.wav";
  if (strcmp(ch, "捏") == 0) return "/words/0531.wav";
  if (strcmp(ch, "捶") == 0) return "/words/0532.wav";
  if (strcmp(ch, "叩") == 0) return "/words/0533.wav";
  if (strcmp(ch, "击") == 0) return "/words/0534.wav";
  if (strcmp(ch, "拍") == 0) return "/words/0535.wav";
  if (strcmp(ch, "打") == 0) return "/words/0536.wav";
  if (strcmp(ch, "振") == 0) return "/words/0537.wav";
  if (strcmp(ch, "颤") == 0) return "/words/0538.wav";
  if (strcmp(ch, "搓") == 0) return "/words/0539.wav";
  if (strcmp(ch, "滚") == 0) return "/words/0540.wav";
  if (strcmp(ch, "摇") == 0) return "/words/0541.wav";
  if (strcmp(ch, "扳") == 0) return "/words/0542.wav";
  if (strcmp(ch, "牵") == 0) return "/words/0543.wav";
  if (strcmp(ch, "伸") == 0) return "/words/0544.wav";
  if (strcmp(ch, "松") == 0) return "/words/0545.wav";
  if (strcmp(ch, "肌") == 0) return "/words/0546.wav";
  if (strcmp(ch, "筋") == 0) return "/words/0547.wav";
  if (strcmp(ch, "络") == 0) return "/words/0548.wav";
  if (strcmp(ch, "穴") == 0) return "/words/0549.wav";
  if (strcmp(ch, "足") == 0) return "/words/0550.wav";
  if (strcmp(ch, "三") == 0) return "/words/0551.wav";
  if (strcmp(ch, "里") == 0) return "/words/0552.wav";
  if (strcmp(ch, "合") == 0) return "/words/0553.wav";
  if (strcmp(ch, "谷") == 0) return "/words/0554.wav";
  if (strcmp(ch, "内") == 0) return "/words/0555.wav";
  if (strcmp(ch, "关") == 0) return "/words/0556.wav";
  if (strcmp(ch, "涌") == 0) return "/words/0557.wav";
  if (strcmp(ch, "泉") == 0) return "/words/0558.wav";
  if (strcmp(ch, "百") == 0) return "/words/0559.wav";
  if (strcmp(ch, "会") == 0) return "/words/0560.wav";
  if (strcmp(ch, "风") == 0) return "/words/0561.wav";
  if (strcmp(ch, "池") == 0) return "/words/0562.wav";
  if (strcmp(ch, "太") == 0) return "/words/0563.wav";
  if (strcmp(ch, "阳") == 0) return "/words/0564.wav";
  if (strcmp(ch, "印") == 0) return "/words/0565.wav";
  if (strcmp(ch, "堂") == 0) return "/words/0566.wav";
  if (strcmp(ch, "膻") == 0) return "/words/0567.wav";
  if (strcmp(ch, "中") == 0) return "/words/0568.wav";
  if (strcmp(ch, "脘") == 0) return "/words/0569.wav";
  if (strcmp(ch, "天") == 0) return "/words/0570.wav";
  if (strcmp(ch, "枢") == 0) return "/words/0571.wav";
  if (strcmp(ch, "气") == 0) return "/words/0572.wav";
  if (strcmp(ch, "海") == 0) return "/words/0573.wav";
  if (strcmp(ch, "关") == 0) return "/words/0574.wav";
  if (strcmp(ch, "元") == 0) return "/words/0575.wav";
  if (strcmp(ch, "命") == 0) return "/words/0576.wav";
  if (strcmp(ch, "门") == 0) return "/words/0577.wav";
  if (strcmp(ch, "肾") == 0) return "/words/0578.wav";
  if (strcmp(ch, "俞") == 0) return "/words/0579.wav";
  if (strcmp(ch, "肺") == 0) return "/words/0580.wav";
  if (strcmp(ch, "俞") == 0) return "/words/0581.wav";
  if (strcmp(ch, "心") == 0) return "/words/0582.wav";
  if (strcmp(ch, "俞") == 0) return "/words/0583.wav";
  if (strcmp(ch, "膈") == 0) return "/words/0584.wav";
  if (strcmp(ch, "俞") == 0) return "/words/0585.wav";
  if (strcmp(ch, "胆") == 0) return "/words/0586.wav";
  if (strcmp(ch, "胃") == 0) return "/words/0587.wav";
  if (strcmp(ch, "脾") == 0) return "/words/0588.wav";
  if (strcmp(ch, "大") == 0) return "/words/0589.wav";
  if (strcmp(ch, "肠") == 0) return "/words/0590.wav";
  if (strcmp(ch, "脉") == 0) return "/words/0591.wav";
  if (strcmp(ch, "青") == 0) return "/words/0592.wav";
  if (strcmp(ch, "灵") == 0) return "/words/0593.wav";
  if (strcmp(ch, "道") == 0) return "/words/0594.wav";
  if (strcmp(ch, "隐") == 0) return "/words/0595.wav";
  if (strcmp(ch, "白") == 0) return "/words/0596.wav";
  if (strcmp(ch, "太") == 0) return "/words/0597.wav";
  if (strcmp(ch, "冲") == 0) return "/words/0598.wav";
  if (strcmp(ch, "行") == 0) return "/words/0599.wav";
  if (strcmp(ch, "间") == 0) return "/words/0600.wav";
  if (strcmp(ch, "丘") == 0) return "/words/0601.wav";
  if (strcmp(ch, "墟") == 0) return "/words/0602.wav";
  if (strcmp(ch, "照") == 0) return "/words/0603.wav";
  if (strcmp(ch, "海") == 0) return "/words/0604.wav";
  if (strcmp(ch, "复") == 0) return "/words/0605.wav";
  if (strcmp(ch, "溜") == 0) return "/words/0606.wav";
  if (strcmp(ch, "阴") == 0) return "/words/0607.wav";
  if (strcmp(ch, "陵") == 0) return "/words/0608.wav";
  if (strcmp(ch, "泉") == 0) return "/words/0609.wav";
  if (strcmp(ch, "阳") == 0) return "/words/0610.wav";
  if (strcmp(ch, "陵") == 0) return "/words/0611.wav";
  if (strcmp(ch, "泉") == 0) return "/words/0612.wav";
  if (strcmp(ch, "绝") == 0) return "/words/0613.wav";
  if (strcmp(ch, "骨") == 0) return "/words/0614.wav";
  if (strcmp(ch, "悬") == 0) return "/words/0615.wav";
  if (strcmp(ch, "钟") == 0) return "/words/0616.wav";
  if (strcmp(ch, "列") == 0) return "/words/0617.wav";
  if (strcmp(ch, "缺") == 0) return "/words/0618.wav";
  if (strcmp(ch, "太") == 0) return "/words/0619.wav";
  if (strcmp(ch, "渊") == 0) return "/words/0620.wav";
  if (strcmp(ch, "鱼") == 0) return "/words/0621.wav";
  if (strcmp(ch, "际") == 0) return "/words/0622.wav";
  if (strcmp(ch, "少") == 0) return "/words/0623.wav";
  if (strcmp(ch, "商") == 0) return "/words/0624.wav";
  if (strcmp(ch, "商") == 0) return "/words/0625.wav";
  if (strcmp(ch, "阳") == 0) return "/words/0626.wav";
  if (strcmp(ch, "合") == 0) return "/words/0627.wav";
  if (strcmp(ch, "腕") == 0) return "/words/0628.wav";
  if (strcmp(ch, "骨") == 0) return "/words/0629.wav";
  if (strcmp(ch, "皆") == 0) return "/words/0630.wav";
  if (strcmp(ch, "使") == 0) return "/words/0631.wav";
  if (strcmp(ch, "津") == 0) return "/words/0632.wav";
  if (strcmp(ch, "液") == 0) return "/words/0633.wav";
  if (strcmp(ch, "血") == 0) return "/words/0634.wav";
  if (strcmp(ch, "虚") == 0) return "/words/0635.wav";
  if (strcmp(ch, "寒") == 0) return "/words/0636.wav";
  if (strcmp(ch, "湿") == 0) return "/words/0637.wav";
  if (strcmp(ch, "热") == 0) return "/words/0638.wav";
  if (strcmp(ch, "风") == 0) return "/words/0639.wav";
  if (strcmp(ch, "邪") == 0) return "/words/0640.wav";
  if (strcmp(ch, "毒") == 0) return "/words/0641.wav";
  if (strcmp(ch, "邪") == 0) return "/words/0642.wav";
  if (strcmp(ch, "外") == 0) return "/words/0643.wav";
  if (strcmp(ch, "感") == 0) return "/words/0644.wav";
  if (strcmp(ch, "内") == 0) return "/words/0645.wav";
  if (strcmp(ch, "伤") == 0) return "/words/0646.wav";
  if (strcmp(ch, "七") == 0) return "/words/0647.wav";
  if (strcmp(ch, "情") == 0) return "/words/0648.wav";
  if (strcmp(ch, "六") == 0) return "/words/0649.wav";
  if (strcmp(ch, "道") == 0) return "/words/0650.wav";
  if (strcmp(ch, "德") == 0) return "/words/0651.wav";
  if (strcmp(ch, "观") == 0) return "/words/0652.wav";
  if (strcmp(ch, "份") == 0) return "/words/0653.wav";
  if (strcmp(ch, "状") == 0) return "/words/0654.wav";
  if (strcmp(ch, "况") == 0) return "/words/0655.wav";
  if (strcmp(ch, "演") == 0) return "/words/0656.wav";
  if (strcmp(ch, "变") == 0) return "/words/0657.wav";
  if (strcmp(ch, "趋") == 0) return "/words/0658.wav";
  if (strcmp(ch, "势") == 0) return "/words/0659.wav";
  if (strcmp(ch, "预") == 0) return "/words/0660.wav";
  if (strcmp(ch, "后") == 0) return "/words/0661.wav";
  if (strcmp(ch, "转") == 0) return "/words/0662.wav";
  if (strcmp(ch, "归") == 0) return "/words/0663.wav";
  if (strcmp(ch, "调") == 0) return "/words/0664.wav";
  if (strcmp(ch, "节") == 0) return "/words/0665.wav";
  if (strcmp(ch, "免") == 0) return "/words/0666.wav";
  if (strcmp(ch, "疫") == 0) return "/words/0667.wav";
  if (strcmp(ch, "增") == 0) return "/words/0668.wav";
  if (strcmp(ch, "强") == 0) return "/words/0669.wav";
  if (strcmp(ch, "减") == 0) return "/words/0670.wav";
  if (strcmp(ch, "延") == 0) return "/words/0671.wav";
  if (strcmp(ch, "迟") == 0) return "/words/0672.wav";
  if (strcmp(ch, "耐") == 0) return "/words/0673.wav";
  if (strcmp(ch, "受") == 0) return "/words/0674.wav";
  if (strcmp(ch, "力") == 0) return "/words/0675.wav";
  if (strcmp(ch, "抵") == 0) return "/words/0676.wav";
  if (strcmp(ch, "抗") == 0) return "/words/0677.wav";
  if (strcmp(ch, "力") == 0) return "/words/0678.wav";
  if (strcmp(ch, "稳") == 0) return "/words/0679.wav";
  if (strcmp(ch, "定") == 0) return "/words/0680.wav";
  if (strcmp(ch, "改") == 0) return "/words/0681.wav";
  if (strcmp(ch, "善") == 0) return "/words/0682.wav";
  if (strcmp(ch, "帮") == 0) return "/words/0683.wav";
  if (strcmp(ch, "助") == 0) return "/words/0684.wav";
  if (strcmp(ch, "作") == 0) return "/words/0685.wav";
  if (strcmp(ch, "用") == 0) return "/words/0686.wav";
  if (strcmp(ch, "药") == 0) return "/words/0687.wav";
  if (strcmp(ch, "信") == 0) return "/words/0688.wav";
  if (strcmp(ch, "提") == 0) return "/words/0689.wav";
  if (strcmp(ch, "供") == 0) return "/words/0690.wav";
  if (strcmp(ch, "参") == 0) return "/words/0691.wav";
  if (strcmp(ch, "考") == 0) return "/words/0692.wav";
  if (strcmp(ch, "依") == 0) return "/words/0693.wav";
  if (strcmp(ch, "据") == 0) return "/words/0694.wav";
  if (strcmp(ch, "请") == 0) return "/words/0695.wav";
  if (strcmp(ch, "勿") == 0) return "/words/0696.wav";
  if (strcmp(ch, "自") == 0) return "/words/0697.wav";
  if (strcmp(ch, "行") == 0) return "/words/0698.wav";
  if (strcmp(ch, "诊") == 0) return "/words/0699.wav";
  if (strcmp(ch, "断") == 0) return "/words/0700.wav";
  if (strcmp(ch, "治") == 0) return "/words/0701.wav";
  if (strcmp(ch, "疗") == 0) return "/words/0702.wav";
  if (strcmp(ch, "情") == 0) return "/words/0703.wav";
  if (strcmp(ch, "严") == 0) return "/words/0704.wav";
  if (strcmp(ch, "重") == 0) return "/words/0705.wav";
  if (strcmp(ch, "应") == 0) return "/words/0706.wav";
  if (strcmp(ch, "及") == 0) return "/words/0707.wav";
  if (strcmp(ch, "时") == 0) return "/words/0708.wav";
  if (strcmp(ch, "就") == 0) return "/words/0709.wav";
  if (strcmp(ch, "按") == 0) return "/words/0710.wav";
  if (strcmp(ch, "嘱") == 0) return "/words/0711.wav";
  if (strcmp(ch, "继") == 0) return "/words/0712.wav";
  if (strcmp(ch, "续") == 0) return "/words/0713.wav";
  if (strcmp(ch, "加") == 0) return "/words/0714.wav";
  if (strcmp(ch, "加") == 0) return "/words/0715.wav";
  if (strcmp(ch, "深") == 0) return "/words/0716.wav";
  if (strcmp(ch, "了") == 0) return "/words/0717.wav";
  if (strcmp(ch, "解") == 0) return "/words/0718.wav";
  if (strcmp(ch, "认") == 0) return "/words/0719.wav";
  if (strcmp(ch, "识") == 0) return "/words/0720.wav";
  if (strcmp(ch, "掌") == 0) return "/words/0721.wav";
  if (strcmp(ch, "方") == 0) return "/words/0722.wav";
  if (strcmp(ch, "法") == 0) return "/words/0723.wav";
  if (strcmp(ch, "注") == 0) return "/words/0724.wav";
  if (strcmp(ch, "意") == 0) return "/words/0725.wav";
  if (strcmp(ch, "事") == 0) return "/words/0726.wav";
  if (strcmp(ch, "项") == 0) return "/words/0727.wav";
  if (strcmp(ch, "并") == 0) return "/words/0728.wav";
  if (strcmp(ch, "祝") == 0) return "/words/0729.wav";
  if (strcmp(ch, "您") == 0) return "/words/0730.wav";
  if (strcmp(ch, "早") == 0) return "/words/0731.wav";
  if (strcmp(ch, "日") == 0) return "/words/0732.wav";
  if (strcmp(ch, "康") == 0) return "/words/0733.wav";
  if (strcmp(ch, "复") == 0) return "/words/0734.wav";
  if (strcmp(ch, "身") == 0) return "/words/0735.wav";
  if (strcmp(ch, "体") == 0) return "/words/0736.wav";
  if (strcmp(ch, "健") == 0) return "/words/0737.wav";
  if (strcmp(ch, "康") == 0) return "/words/0738.wav";
  if (strcmp(ch, "常") == 0) return "/words/0739.wav";
  if (strcmp(ch, "运") == 0) return "/words/0740.wav";
  if (strcmp(ch, "动") == 0) return "/words/0741.wav";
  if (strcmp(ch, "锻") == 0) return "/words/0742.wav";
  if (strcmp(ch, "炼") == 0) return "/words/0743.wav";
  if (strcmp(ch, "愉") == 0) return "/words/0744.wav";
  if (strcmp(ch, "悦") == 0) return "/words/0745.wav";
  if (strcmp(ch, "乐") == 0) return "/words/0746.wav";
  if (strcmp(ch, "观") == 0) return "/words/0747.wav";
  if (strcmp(ch, "看") == 0) return "/words/0748.wav";
  if (strcmp(ch, "待") == 0) return "/words/0749.wav";
  if (strcmp(ch, "配") == 0) return "/words/0750.wav";
  if (strcmp(ch, "合") == 0) return "/words/0751.wav";
  if (strcmp(ch, "收") == 0) return "/words/0752.wav";
  if (strcmp(ch, "获") == 0) return "/words/0753.wav";
  if (strcmp(ch, "效") == 0) return "/words/0754.wav";
  if (strcmp(ch, "果") == 0) return "/words/0755.wav";
  if (strcmp(ch, "满") == 0) return "/words/0756.wav";
  if (strcmp(ch, "意") == 0) return "/words/0757.wav";
  if (strcmp(ch, "坚") == 0) return "/words/0758.wav";
  if (strcmp(ch, "持") == 0) return "/words/0759.wav";
  if (strcmp(ch, "住") == 0) return "/words/0760.wav";
  if (strcmp(ch, "习") == 0) return "/words/0761.wav";
  if (strcmp(ch, "惯") == 0) return "/words/0762.wav";
  if (strcmp(ch, "养") == 0) return "/words/0763.wav";
  if (strcmp(ch, "成") == 0) return "/words/0764.wav";
  if (strcmp(ch, "为") == 0) return "/words/0765.wav";
  if (strcmp(ch, "贵") == 0) return "/words/0766.wav";
  if (strcmp(ch, "预") == 0) return "/words/0767.wav";
  if (strcmp(ch, "防") == 0) return "/words/0768.wav";
  if (strcmp(ch, "胜") == 0) return "/words/0769.wav";
  if (strcmp(ch, "于") == 0) return "/words/0770.wav";
  if (strcmp(ch, "治") == 0) return "/words/0771.wav";
  if (strcmp(ch, "疗") == 0) return "/words/0772.wav";
  return "";
}
